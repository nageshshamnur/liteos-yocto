FILESEXTRAPATHS_prepend_stm32mp1-av96-common := "${THISDIR}/${PN}:"
