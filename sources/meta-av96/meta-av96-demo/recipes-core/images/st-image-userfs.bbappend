# Add specific package for our image:
PACKAGE_INSTALL_stm32mp1-av96-common += " \
    m4projects-av96-userfs \
    "

